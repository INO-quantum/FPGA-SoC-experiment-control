#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " dio24"
IMAGE_INSTALL_append = " FPGA-test"
IMAGE_INSTALL_append = " FPGA-server"
IMAGE_INSTALL_append = " FPGA-init"
IMAGE_INSTALL_append = " FPGA-exit"
