SRC_URI_append = " file://platform-top.h"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://user_2020-09-14-01-01-00.cfg"

