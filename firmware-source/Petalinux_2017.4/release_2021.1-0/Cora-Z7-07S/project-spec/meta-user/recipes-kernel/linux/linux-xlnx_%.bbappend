SRC_URI += "file://user_2018-04-30-10-48-00.cfg \
            file://user_2018-04-30-12-59-00.cfg \
            file://user_2020-07-21-23-30-00.cfg \
            file://user_2020-07-22-08-48-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

